Commit message: Small changes

File: src/capstone_arm/urdf/capstone_arm.urdf (robot description, URDF)
Before this commit: robot capstone_arm, 7 links, 6 joints
Joints:
- joint joint6: limit lower=-1.37 upper=1.37 effort=50 velocity=10 -> lower=-1.30 upper=1.30 effort=50 velocity=10
